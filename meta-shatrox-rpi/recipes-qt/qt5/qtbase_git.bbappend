PACKAGECONFIG:append = " accessibility eglfs fontconfig freetype gles2 linuxfb tslib"

DEPENDS += "userland"

